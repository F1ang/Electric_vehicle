# IAR project GPIO_LED_Toggle.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F5333D7PV MindMotion MM32F5333D7PV
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 70
  General.FPU2: 6
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; CUSTOM_HSE_VAL
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\Device\CMSIS\Core\Include; ..\..\..\..\..\Device\MM32F5330\HAL_Lib\inc; ..\..\..\..\..\Device\MM32F5330\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GPIO_LED_Toggle.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../: main.c mm32f5330_it.c gpio_led_toggle.c platform.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../../../../Device/MM32F5330/HAL_Lib/src/: hal_adc.c hal_bkp.c hal_comp.c hal_cordic.c hal_crcpoly.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_i2c.c hal_i3c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_mds.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_sram.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_usart.c hal_wwdg.c
  group STARTUP
    ../../../../../Device/MM32F5330/Source/IAR_StartAsm/: startup_mm32f5330_iar.s
    ../../../../../Device/MM32F5330/Source/: system_mm32f5330.c
