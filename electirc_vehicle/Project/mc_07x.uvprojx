# Keil uVision project mc_07x.uvprojx, settings and files
target Lks_07x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC071CBT8 Linko
  pack: Linko.LKS07x.1.2.0
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lks07x_Project +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c include: ..\Driver\Include;..\Core\inc;..\Hardware\inc;..\AppFunction\inc;..\FOC\inc;..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT5: ROM 0x1fe00 size 0x200
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Driver
    ../Driver/Source/: lks32mc07x_adc.c lks32mc07x_can.c lks32mc07x_cmp.c lks32mc07x_dac.c lks32mc07x_dma.c lks32mc07x_dsp.c lks32mc07x_exti.c lks32MC07x_flash.c lks32mc07x_gpio.c lks32mc07x_hall.c lks32mc07x_mcpwm.c lks32mc07x_nvr.lib lks32mc07x_opa.c lks32mc07x_qep.c lks32mc07x_sif.c lks32mc07x_sys.c lks32mc07x_tim.c lks32mc07x_tmp.c lks32mc07x_uart.c lks32mc07x_wake.c
  group Startup
    ../Startup/: startup_lks32mc07x.s
  group Core
    ../Core/src/: interrupt.c main.c
  group Hardware
    ../Hardware/src/: hardware_init.c mc_math.c pid_regulators.c
  group AppFunction
    ../AppFunction/src/: global_variable.c state_machine.c task_scheduler.c
  group FOC
    ../FOC/src/: foc_drive.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.4.0
